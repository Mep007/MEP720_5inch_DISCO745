# IAR project STM32H745I_DISCO.ewp, settings and files
configuration STM32H745I_DISCO_CM4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H745I-DISCO_M4 ST STM32H745I-DISCO_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32H745xx; USE_BPP=16; USE_PWR_DIRECT_SMPS_SUPPLY
  ICCARM.CCIncludePath2: ../CM4/Core/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../CM4/Core/Inc
  OBJCOPY.OOCOutputFile: stm32h745i_disco_CM4.hex
  ILINK.IlinkOutputFile: STM32H745I_DISCO_CM4.out
  ILINK.IlinkIcfFile: stm32h745xx_flash_CM4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32H745I_DISCO_CM7 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H745I-DISCO_M7 ST STM32H745I-DISCO_M7
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H745xx; USE_PWR_DIRECT_SMPS_SUPPLY
  ICCARM.CCIncludePath2: ../CM7/Core/Inc; ../CM7/TouchGFX/App; ../CM7/TouchGFX/target/generated; ../CM7/TouchGFX/target; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include; ../CM7/Middlewares/ST/touchgfx/framework/include; ../CM7/TouchGFX/generated/fonts/include; ../CM7/TouchGFX/generated/images/include; ../CM7/TouchGFX/generated/texts/include; ../CM7/TouchGFX/generated/gui_generated/include; ../CM7/TouchGFX/gui/include; ../Drivers/BSP/Components/Common; ../Drivers/BSP/STM32H745I-DISCO; ../Utilities/JPEG; ../CM7/TouchGFX/generated/videos/include
  AARM.AUserIncludes: ../CM7/Core/Inc
  OBJCOPY.OOCOutputFile: stm32h745i_disco_CM7.hex
  ILINK.IlinkOutputFile: STM32H745I_DISCO_CM7.out
  ILINK.IlinkIcfFile: stm32h745xx_flash_CM7.icf
  ILINK.IlinkAdditionalLibs: ../CM7/Middlewares/ST/touchgfx/lib/core/cortex_m7/IAR8.x/touchgfx_core.a
  group Application/EWARM
    ./: startup_stm32h745xx_CM4.s startup_stm32h745xx_CM7.s
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/CM7/Core
    ../CM7/Core/Src/: main_user.c main.c freertos.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/CM7/TouchGFX/App
    ../CM7/TouchGFX/App/: app_touchgfx.c
  group Application/User/CM7/TouchGFX/target
    ../CM7/TouchGFX/target/: STM32H7Instrumentation.cpp stm32h745i_touchcontroller.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/CM7/TouchGFX/target/generated
    ../CM7/TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp HardwareMJPEGDecoder.cpp
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
    ../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
    ../Drivers/BSP/Components/mt48lc4m32b2/: mt48lc4m32b2.c
  group Drivers/BSP/STM32H745I-DISCO
    ../Drivers/BSP/STM32H745I-DISCO/: stm32h745i_discovery.c stm32h745i_discovery_bus.c stm32h745i_discovery_lcd.c stm32h745i_discovery_qspi.c stm32h745i_discovery_sdram.c stm32h745i_discovery_ts.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_qspi.c stm32h7xx_ll_delayblock.c
  group generated/fonts
    ../CM7/TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_verdana_10_4bpp_0.cpp Font_verdana_20_4bpp_0.cpp Font_verdana_40_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_40_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_40_4bpp.cpp UnmappedDataFont.cpp
  group generated/gui_generated/common
    ../CM7/TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group generated/gui_generated/screen1_screen
    ../CM7/TouchGFX/generated/gui_generated/src/screen1_screen/: Screen1ViewBase.cpp
  group generated/images
    ../CM7/TouchGFX/generated/images/src/: BitmapDatabase.cpp SVGDatabase.cpp
  group generated/images/__generated
    ../CM7/TouchGFX/generated/images/src/__generated/: image_light_theme_images_backgrounds_480x272_worn_paint.cpp
  group generated/texts
    ../CM7/TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group gui/common
    ../CM7/TouchGFX/gui/src/common/: FrontendApplication.cpp
  group gui/model
    ../CM7/TouchGFX/gui/src/model/: Model.cpp
  group gui/screen1_screen
    ../CM7/TouchGFX/gui/src/screen1_screen/: Screen1Presenter.cpp Screen1View.cpp
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Utilities
    ../Utilities/JPEG/: jpeg_utils.c
